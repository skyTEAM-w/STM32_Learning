# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\beep;.\APP\wkup;.\APP\touch_key;.\APP\adc;.\APP\adc_temp;.\APP\lsens;.\APP\dac;.\APP\pwm_dac;.\APP\dma;.\APP\rtc;.\APP\iic;.\APP\24cxx;.\APP\can;.\APP\tftlcd;.\APP\spi;.\APP\flash;.\APP\stm32_flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_flash.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/adc_temp/: adc_temp.c
    ./APP/adc/: adc.c
    ./APP/lsens/: lsens.c
    ./APP/dac/: dac.c
    ./APP/key/: key.c
    ./APP/pwm/: pwm.c
    ./APP/pwm_dac/: pwm_dac.c
    ./APP/dma/: dma.c
    ./APP/rtc/: rtc.c
    ./APP/iic/: iic.c
    ./APP/24cxx/: 24cxx.c
    ./APP/can/: can.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/spi/: spi.c
    ./APP/flash/: flash.c
    ./APP/stm32_flash/: stm32_flash.c
  group Public
    ./Public/: system.c SysTick.c usart.c
